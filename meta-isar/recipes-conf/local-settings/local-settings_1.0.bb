# ---------------------------------------------------------------------------
# This Isar layer is part of MTDA
# Copyright (s) Siemens AG, 2022
# ---------------------------------------------------------------------------
# SPDX-License-Identifier: MIT
# ---------------------------------------------------------------------------

inherit dpkg-raw

MAINTAINER = "mtda-users <mtda-users@googlegroups.com>"

include local.inc

do_install() {
}
