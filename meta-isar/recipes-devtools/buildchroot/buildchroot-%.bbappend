# This Isar layer is part of MTDA
# Copyright (C) 2017-2019 Mentor Graphics, a Siemens business

BUILDCHROOT_PREINSTALL_append = " git "
